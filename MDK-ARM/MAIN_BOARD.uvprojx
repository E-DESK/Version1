# Keil uVision project MAIN_BOARD.uvprojx, settings and files
target STM32F407 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: MAIN_BOARD +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,HSE_VALUE=8000000,TM_DISCO_STM32F4_DISCOVERY,ARM_MATH_CM4
  c include: ..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\User;..\Utilities;..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\Libraries\CMSIS\Include;..\FATFS;..\TM;..\FATFS\drivers;..\FATFS\option;..\ESP8266;..\FreeRTOS;..\FreeRTOS\Source\include;..\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\Fuzzy;..\Libraries\00-STM32F4xx_STANDARD_PERIPHERAL_DRIVERS\CMSIS\Include;..\Libraries\00-STM32F4xx_STANDARD_PERIPHERAL_DRIVERS\CMSIS\DSP_Lib
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ../User/: main.c stm32f4xx_it.c system_stm32f4xx.c TFT.c
    ../Libraries/00-STM32F4xx_STANDARD_PERIPHERAL_DRIVERS/CMSIS/DSP_Lib/Source/ControllerFunctions/: arm_pid_init_f32.c arm_pid_init_q15.c arm_pid_init_q31.c arm_pid_reset_f32.c arm_pid_reset_q15.c arm_pid_reset_q31.c arm_sin_cos_f32.c arm_sin_cos_q31.c
  group STM32F4xx_StdPeriph_Driver
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_wwdg.c
  group CMSIS
    ../User/: system_stm32f4xx.c
  group MDK-ARM
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40_41xxx.s
  group Utilities
    ../Utilities/: AsciiLib.c SSD1289.c BH1750.c DHT11.c I2C1.c
  group FATFS
    ../FATFS/: fattime.c ff.c diskio.c
    ../FATFS/option/: ccsbcs.c
  group TM
    ../TM/: tm_stm32f4_rtc.c tm_stm32f4_nrf24l01.c tm_stm32f4_spi.c tm_stm32f4_gpio.c tm_stm32f4_disco.c tm_stm32f4_ds1307.c tm_stm32f4_i2c.c tm_stm32f4_delay.c tm_stm32f4_usart.c tm_stm32f4_timer_properties.c tm_stm32f4_adc.c tm_stm32f4_pwm.c
  group ESP8266
    ../ESP8266/: esp8266.c
  group FreeRTOS
    ../FreeRTOS/Source/: queue.c tasks.c list.c croutine.c timers.c
    ../FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../FreeRTOS/Source/portable/MemMang/: heap_2.c
  group Forecast
    ../Forecast/: Forecast.c
  group nrf024l01
    ../Utilities/: nrf24l01.c
